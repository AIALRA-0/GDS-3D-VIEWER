VERSION 5.8 ;
BUSBITCHARS "[]" ;
DIVIDERCHAR "/" ;
UNITS
  DATABASE MICRONS 1000 ;
END UNITS
MACRO OPENROAD_DEMO
  CLASS BLOCK ;
  ORIGIN 0 0 ;
  SIZE 10 BY 10 ;
END OPENROAD_DEMO
END LIBRARY
